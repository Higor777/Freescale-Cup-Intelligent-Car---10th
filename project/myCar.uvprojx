# Keil uVision project myCar.uvprojx, settings and files
target myCar (ARM-ADS)
  device: MKL26Z256xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: myCar
  c flags: Optim=1 uC99=1 wLevel=2
  c define: MKL26Z4
  c include: ..\app;..\devices;..\drivers\inc;..\usmart
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group app
    ../app/: catchline.c ctrl.c Debug.c filter.c main.c umc.c sprint.c remote.c
  group cfg
    ../cfg/: cfg.h
  group devices
    ../devices/: anglesensor.c BatteryMon.c bluetooth.c ccd.c encoder.c KEY.c motor.c oled.c led.c IR.c
  group drivers
    ../drivers/src/: adc.c common.c dma.c gpio.c i2c.c pit.c systick.c tpm.c uart.c spi.c
  group usmart
    ../usmart/: usmart.c usmart_config.c usmart_str.c
  group ::Device
    RTE/Device/MKL26Z256xxx4/: startup_MKL26Z4.s system_MKL26Z4.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
